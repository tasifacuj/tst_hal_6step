<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\tst_hal_6step.ewp</path>
  </project>
  <batchBuild />
</workspace>
